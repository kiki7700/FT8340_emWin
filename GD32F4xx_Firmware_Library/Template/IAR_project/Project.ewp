# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F470xE GD GD32F470xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F4XX_HD
  ICCARM.CCIncludePath2: ..; ..\..\Firmware\GD32F4xx_standard_peripheral\Include; ..\..\Firmware\CMSIS; ..\..\Firmware\CMSIS\GD\GD32F4xx\Include; ..\..\Firmware\CMSIS\GD; ..\..\Utilities; D:\GD32F470\project\FT8340_emWin\GD32F4xx_Firmware_Library\Firmware\emWin\inc; D:\GD32F470\project\FT8340_emWin\GD32F4xx_Firmware_Library\Firmware\emWin\config; D:\GD32F470\project\FT8340_emWin\GD32F4xx_Firmware_Library\Firmware\LCD
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F470xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../: gd32f4xx_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Doc
    ../: readme.txt
  group emWin
    ../../Firmware/emWin/OS/: GUI_X.c
    ../../Firmware/emWin/config/: GUIConf.c LCDConf_FlexColor_Template.c
    ../../Firmware/emWin/Lib/: STemWin_CM4_wc32_ARGB.a
  group GD32F4xx_EVAL
    ../../Utilities/: gd32f450i_eval.c
  group GD32F4xx_Peripherals
    ../../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F4xx/Source/IAR/: startup_gd32f450_470.s
